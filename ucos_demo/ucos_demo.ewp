# IAR project ucos_demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; ..\uCOS_II\uCOS-II\Source; ..\uCOS_II\uCOS-II\Ports; ..\uCOS_II\uC-CPU; ..\uCOS_II\uC-CPU\MSP430; ..\uCOS_II\uC-LIB; BSP; OS2
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: DISABLE_WATCHDOG; USE_LARGE_CODE_MODEL
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group APP
    OS2/: app.c app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group BSP
    BSP/: bsp.c bsp.h
  group uC_CPU
    ../uCOS_II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC_CPU/MSP430
    ../uCOS_II/uC-CPU/MSP430/: cpu.h
  group uCOS_II/Ports
    ../uCOS_II/uCOS-II/Ports/: os_cpu.h os_cpu_a.s43 os_cpu_c.c os_dbg.c
  group uCOS_II/Source
    ../uCOS_II/uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
