# IAR project freertos_demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: IAR_MSP430
  ICC430.newCCIncludePaths: source\; source\board\; source\include\; ..\FreeRTOS\; ..\FreeRTOS\include\; ..\FreeRTOS\portable\IAR_MSP430\; ..\FreeRTOS\portable\MemMang\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group appsrc
    source/: main.c
  group appsrc/board
    source/board/: bsp.c flash.c
  group appsrc/include
    source/include/: bsp.h flash.h FreeRTOSConfig.h
  group freertos
    ../../../Source Code/msp430/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/include
    ../../../Source Code/msp430/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portasm.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/portable
    ../../../Source Code/msp430/FreeRTOS/portable/: heap_1.c port.c portext.s43
